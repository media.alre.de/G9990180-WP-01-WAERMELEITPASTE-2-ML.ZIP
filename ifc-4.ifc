Properties of the parts of a building model (IFC4)

# File
Description: Wärmeleitpaste, 2 ml, -40…+150 °C, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990180, Wärmeleitpaste, 2 ml, -40…+150 °C
In: Raum
Description: Wärmeleitfähigkeit 0,7 W/mK, R < 1 TOhm / cm, silikonfrei; Classification: EC010861 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990180; ModelLabel: WP-01; GlobalTradeItemNumber: 4050528044112; ProductURL: https://alre.de/produkt_G9990180
Pset_Specification - NominalLength: 0.113 m; NominalWidth: 0.021 m; NominalDepth: 0.021 m; NetWeight: 0.007
Pset_ALRE_ETIM_Properties - Verpackung: Spritze; ETIM-Klasse: EC010861; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990180.pdf
